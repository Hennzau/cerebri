## lib/sense/Kconfig
```kconfig
# Copyright (c) 2023 CogniPilot Foundation
# SPDX-License-Identifier: Apache-2.0

menu "Sense"

rsource "imu/Kconfig"
rsource "vesc_can_status/Kconfig"

endmenu
```
